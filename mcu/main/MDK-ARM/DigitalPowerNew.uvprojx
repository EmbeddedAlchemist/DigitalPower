# Keil uVision project DigitalPowerNew.uvprojx, settings and files
target DigitalPowerNew (6190000::V6.19::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DigitalPowerNew +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx, CFG_TUSB_MCU=OPT_MCU_STM32G4, CFG_TUSB_OS=OPT_OS_FREERTOS,USBPD_PORT_COUNT=1,_RTOS,_SNK,USBPDCORE_LIB_PD3_CONFIG_1
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Util;../BSP;../Application;../Hardware;../Application/GUI/drawing;../Application/GUI/fonts;../Application/GUI/ui;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/ST/STM32_USBPD_Library/Core/inc;../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G4XX/inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc
  asm include: ../Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Application/: user_main.cpp gui_thread.cpp usb_thread.cpp impl_usbpd_dpm_user.cpp impl_usbpd_pwr_if.cpp impl_usbpd_pwr_user.cpp power_control_timer_handle.cpp
  group BSP
    ../BSP/: onboad_interrupt_binder.cpp
  group Hardware
    ../Hardware/: buzzer.cpp lcd.cpp console.cpp usb_bridge.cpp onboard_resource.cpp power_sample.cpp tmp102.cpp usbpd.cpp button.cpp encoder.cpp power_control.cpp
  group Application/GUI/Drawing
    ../Application/GUI/drawing/: drawing_interface.cpp font.cpp offset.cpp RGB565.cpp size.cpp utf8_parser.cpp
  group Application/GUI/Fonts
    ../Application/GUI/fonts/: font_Jetbrains_Mono_20px_w800_gs2bit.cpp font_MiSans_10px_w700_gs4bit.cpp font_MiSans_12px_w500_gs4bit.cpp font_MiSans_16px_w500_gs2bit.cpp font_din_coros_56px_w500_gs1bit.cpp
  group Application/GUI/UI
    ../Application/GUI/ui/: main_ui.cpp ui_controler.cpp ui_resource.cpp
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c gpio.c app_freertos.c adc.c comp.c dac.c dma.c i2c.c opamp.c spi.c tim.c ucpd.c usart.c usbpd.c usbpd_dpm_user.c usbpd_pwr_user.c usbpd_pwr_if.c usbpd_vdm_user.c usbpd_dpm_core.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/USBPD
    ../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_CONFIG_1_CM4_Keil.lib
    ../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G4XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Util
    ../Util/: timeout.cpp
software components: CMSIS:CORE 5.6.0
